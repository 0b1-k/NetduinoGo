# IAR project DAQLVModule.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: C:\Projects\GO! Dev\Library; C:\Projects\GO! Dev\STM32\AnalogDataModule; C:\Projects\GO! Dev\STM32\AnalogDataModule\fat_sd; C:\Projects\GO! Dev\STM32\AnalogDataModule\STM32F0-FW_V1.0.0\Libraries\CMSIS\Include; C:\Projects\GO! Dev\STM32\AnalogDataModule\STM32F0-FW_V1.0.0\Libraries\CMSIS\ST\STM32F0xx\Include; C:\Projects\GO! Dev\STM32\AnalogDataModule\STM32F0-FW_V1.0.0\Libraries\STM32F0xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NwazetDAQLVModule.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: DAQLVModule.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; fat_sd; ..\..\Library; STM32F0-FW_V1.0.0\Libraries\CMSIS\Include; STM32F0-FW_V1.0.0\Libraries\CMSIS\ST\STM32F0xx\Include; STM32F0-FW_V1.0.0\Libraries\STM32F0xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ./: Adc.c daqSystemConfig.c digitalgpio.c fshandler.c GoBusModuleID.c i2c.c i2chandler.c lastFunction.c LedController.c main.c message.c peripherals.c rtc.c spi.c stm32f0xx_it.c submessagehandlercontext.c timeouts.c usart.c usarthandler.c vt100.c
  group ARM Libraries/CMSIS/Device
    ./: system_stm32f0xx.c
  group ARM Libraries/CMSIS/Startup
    ./: startup_stm32f0xx.s
  group ARM Libraries/StdPeriph
    STM32F0-FW_V1.0.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group FatFS
    fat_sd/: diskio.c ff.c
  group Nwazet
    ../../Library/: Nwazet.c

# IAR project DisplayModule.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205rx ST STM32F205rx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx\startup\iar; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Library; ; ..\..\Microbuilder; ..\..\Microbuilder\core\adc; ..\..\Microbuilder\core\gpio; ..\..\Microbuilder\core\systick; ..\..\Microbuilder\drivers\eeprom; ..\..\Microbuilder\drivers\lcd; ..\..\Microbuilder\drivers\lcd\tft; ..\..\Microbuilder\drivers\lcd\tft\hw; ..\..\Microbuilder\drivers\lcd\tft\fonts; ..\..\Microbuilder\drivers\lcd\tft\dialogues
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DisplayModule.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: DisplayModule.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: NwazetDisplayModule.bin
  group (top)
    ./: GoBusModuleID.c main.c spi.c stm32f2xx_it.c VirtualCanvas.c
  group ARM Libraries/CMSIS/Device
    ./: system_stm32f2xx.c
  group ARM Libraries/CMSIS/Startup
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
  group ARM Libraries/StdPeriph
    Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c
  group MicroBuilder
    ../../Microbuilder/: License.txt projectconfig.c
  group MicroBuilder/Core/ADC
    ../../Microbuilder/core/adc/: adc.c
  group MicroBuilder/Core/GPIO
    ../../Microbuilder/core/gpio/: gpio.c
  group MicroBuilder/Core/SYSTICK
    ../../Microbuilder/core/systick/: systick.c
  group MicroBuilder/Drivers/EEPROM
    ../../Microbuilder/drivers/eeprom/: eeprom.c
  group MicroBuilder/Drivers/LCD/TFT
    ../../Microbuilder/drivers/lcd/tft/: drawing.c
  group MicroBuilder/Drivers/LCD/TFT/Dialogues
    ../../Microbuilder/drivers/lcd/tft/dialogues/: alphanumeric.c
  group MicroBuilder/Drivers/LCD/TFT/Fonts
    ../../Microbuilder/drivers/lcd/tft/fonts/: dejavusans9.c dejavusansbold9.c dejavusanscondensed9.c dejavusansmono8.c dejavusansmonobold8.c verdana14.c verdana9.c verdanabold14.c
  group MicroBuilder/Drivers/LCD/TFT/HW
    ../../Microbuilder/drivers/lcd/tft/hw/: ILI9341.c
    ../../Microbuilder/drivers/lcd/tft/: touchscreen.c
  group Nwazet
    ../../Library/: Nwazet.c

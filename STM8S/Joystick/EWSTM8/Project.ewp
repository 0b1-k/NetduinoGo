# IAR project Project.ewp, settings and files
configuration STM8S208 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Joystick.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s105c6.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8S207 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S207MB STM8S207MB
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8S207
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8S_EVAL; ..\..\..\Utilities\STM8S_EVAL\STM8S-128_EVAL; ..\..\..\Utilities\STM8S_EVAL\Common
  OBJCOPY.OOCOutputFile: Project.srec
configuration STM8S105 (STM8, debug)
  as the first configuration, except:
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCSTM8.CCIncludePath2: C:\Projects\Netduino Go\nwazet-display-module\STM8S\Joystick; C:\Projects\Netduino Go\nwazet-display-module\STM8S\STM8S_StdPeriph_Driver\inc
  OBJCOPY.OOCOutputFile: Project.srec
configuration STM8S103 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S103K3U STM8S103K3U
  General.GenStackSize: 0x200
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: C:\Projects\GO! Dev\Library; C:\Projects\GO! Dev\STM8S\Joystick; C:\Projects\GO! Dev\STM8S\STM8S_StdPeriph_Driver\inc
  OBJCOPY.OOCOutputFile: NwazetGoJoystick.hex
  ILINK.IlinkOutputFile: NwazetGoJoystick.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s103f3.icf
configuration STM8S903 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S903K3 STM8S903K3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCSTM8.CCDefines: STM8S903
  OBJCOPY.OOCOutputFile: Project.srec
configuration STM8AF52Ax (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF52AA STM8AF52AA
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8AF52Ax
  ICCSTM8.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: Project.srec
configuration STM8AF62Ax (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF62AA STM8AF62AA
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8AF62Ax
  ICCSTM8.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: Project.srec
configuration STM8AF626x (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF6269 STM8AF6269
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCSTM8.CCDefines: STM8AF626x
  OBJCOPY.OOCOutputFile: Project.srec
  group StdPeriph_Drivers
    ../../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group User
    ../: GoBusModuleID.c main.c stm8s_conf.h stm8s_it.c
    ../../../Library/: Nwazet.c
